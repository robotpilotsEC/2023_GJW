# Keil uVision project HeroV1.uvprojx, settings and files
target HeroV1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: HeroV1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1U,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;.\USER\drivers;.\USER\algos;.\USER\configs;.\USER\hardwares;.\USER\tools;.\USER\devices;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;.\USER\tasks;.\USER\modules;.\USER\rp_pack;.\USER\devices\imu;.\USER\protocols
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c iwdg.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_iwdg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group drivers
    ./USER/drivers/: drv_can.c drv_all.c drv_uart.c
  group configs
    ./USER/configs/: config_can.c config_pid.c config_status.c config_uart.c config_remote.c config_imu.c config_gimbal.c config_chassis.c config_shooting.c
  group algos
    ./USER/algos/: pid.c
  group tools
    ./USER/tools/: mathematics.c mean_filter.c ave_filter.c
  group devices
    ./USER/devices/: shooting_motor.c chassis_motor.c gimbal_motor.c imu.c cap.c
  group rp_pack
    ./USER/rp_pack/: motor.c motor_def.h rp_chassis.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group tasks
    ./USER/tasks/: control_task.c
    ./: TobeSolved.txt
  group modules
    ./USER/devices/: remote.c
    ./USER/modules/: shooting.c chassis.c gimbal.c car.c vision.c judge.c to_slave.c
  group imu
    ./USER/devices/imu/: bmi.c bmi2.c bmi2_common.c soft_iic.c bmi270.c bmi270_context.c bmi2_defs.h bmi2_ois.c
    ./USER/drivers/: drv_haltick.c
  group protocols
    ./USER/protocols/: crc8.c crc16.c vision_protocol.c
software components: CMSIS:CORE 4.3.0
